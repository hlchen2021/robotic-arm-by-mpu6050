# Keil uVision project STM32_nrf24l01TX.uvproj, settings and files
target STM32_nrf24l01TX (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_nrf24l01TX +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CMSIS;..\FWLib\inc;..\FWLib\src;.\Hardware;.\System;.\Main
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLib
    ../FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_usart.c
  group STARTCODE
    ../CMSIS/Startup/: startup_stm32f10x_hd.s
  group MAIN
    ./Main/: main.c stm32f10x_it.c
  group System
    ./System/: RCC.c Delay.c EXTI.c TIMx.c ADC.c USART.c
  group Hareware
    ./Hardware/: LED.c Key.c SPI_OLED.c PWM.c BUZZER.c nRF24L01.c AD.c floatturn.c
